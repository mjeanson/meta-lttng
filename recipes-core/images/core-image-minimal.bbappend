IMAGE_INSTALL += " \
	liburcu \
	babeltrace \
	lttng-ust \
	lttng-tools \
	lttng-modules \
	"
